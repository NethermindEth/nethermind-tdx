PACKAGE_INSTALL:append = " jrpc-interceptor"