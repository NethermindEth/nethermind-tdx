include rpc-snooper.inc

SRC_URI = "git://${GO_IMPORT};protocol=https;branch=master"
SRCREV = "${AUTOREV}"

GO_IMPORT = "github.com/Hyodar/rpc-snooper"
