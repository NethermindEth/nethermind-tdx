PACKAGE_INSTALL:append = " taiko-client"
