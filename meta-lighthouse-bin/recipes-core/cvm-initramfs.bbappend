PACKAGE_INSTALL:append = " lighthouse"