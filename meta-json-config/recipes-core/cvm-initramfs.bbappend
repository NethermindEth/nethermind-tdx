PACKAGE_INSTALL:append = " json-config"