PACKAGE_INSTALL:append = " nethermind"