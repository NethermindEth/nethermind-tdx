PACKAGE_INSTALL:append = " tdx-attestor"