PACKAGE_INSTALL:append = " raiko"